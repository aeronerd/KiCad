# Repository aeronerd/KiCad

## KiCad design projects/BikeLightComputerRev2/BikeLightComputerRev2.kicad_pcb

Board: 2 copper layers, 32.3 x 36.3 mm, 27 parts (7 on the bottom side), 19 nets.

Parts:
C1, C2, C3, C4, C5, C6: 1uF; C_0603
IC1, IC2, IC3: MOSFET_SOT223_FQT13N06TF; SOT-223-4
IC4: REG_3V3_NCP1117ST33T3G; SOT-223-4
J1: Barrel_Jack_MountingPin; BARREL_JACK
J3, J4: Conn_01x01_Male; Socket_Strip_Straight_1x01_Pitch2.54mm
J5: Conn_01x04_Female; Socket_Strip_Straight_1x04_Pitch2.54mm
J6, J7, J8, J9: Conn_01x01_Male; Measurement_Point_Square-SMD-Pad_Big
J10, J11, J12, J13, J14, J15: Conn_01x01_Male; Measurement_Point_Round-SMD-Pad_Small
J16: Conn_01x03_Male; Socket_Strip_Straight_1x03_Pitch2.54mm
U1: ATMEGA328P-MU
U2: RF4463PRO_LiteralLayout

Connections:
AVR_PWM_BLUE: IC3.1, U1.1
AVR_PWM_GREEN: IC2.1, U1.14
AVR_PWM_RED: IC1.1, U1.13
AVR_SER_RX: J5.2, U1.30
AVR_SER_TX: J5.1, U1.31
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.1, IC1.3, IC2.3, IC3.3, IC4.1, J1.2, J4.1, J5.3, J15.1, U1.3, U1.5, U1.21, U1.33, U2.1, U2.12, U2.13
unnamed: IC1.4, J7.1
unnamed: IC2.4, J8.1
unnamed: IC3.4, J9.1
unnamed: J1.1, J3.1, J16.2
RADIO_NIRQ: U1.10, U2.10
RADIO_NSEL: U1.12, U2.9
RADIO_SDN: U1.11, U2.11
SPI_MISO: J10.1, U1.16, U2.6
SPI_MOSI: J14.1, U1.15, U2.7
SPI_RESET: J12.1, U1.29
SPI_SCK: J11.1, U1.17, U2.8
VCC: C1.2, C2.2, C3.2, C4.2, C6.2, IC4.2, IC4.4, J5.4, J13.1, U1.4, U1.6, U1.18, U2.5
VOLTAGE_INPUT: C5.1, IC4.3, J6.1, J16.1

## KiCad design projects/BreakoutSI4463PRORev3/BreakoutSI4463PRORev3.kicad_pcb

Parts:
J1: Conn_Coaxial; SMA_EdgeMount_BackOnly
J2, J3, J5, J6: Conn_01x01_Female; Pin_Header_Straight_1x01_Pitch2.54mm
J4: Conn_01x08_Female; Pin_Header_Straight_1x08_Pitch2.54mm
U1: RF4463PRO_LiteralLayout

Connections:
GND: J1.2 (Ext), J4.1, J6.1, U1.1 (GND), U1.12 (GND), U1.13 (GND)
unnamed: J1.1 (In), J5.1, U1.14 (ANT)
unnamed: J2.1, U1.3 (GPIO0)
unnamed: J3.1, U1.4 (GPIO1)
unnamed: J4.2, U1.11 (SDN)
unnamed: J4.3, U1.10 (NIRQ)
unnamed: J4.4, U1.9 (NSEL)
unnamed: J4.5, U1.8 (SCLK)
unnamed: J4.6, U1.7 (SDI)
unnamed: J4.7, U1.6 (SDO)
unnamed: J4.8, U1.5 (VCC)

Board: 2 copper layers, 22.4 x 20.8 mm, 7 parts (0 on the bottom side), 11 nets.

## KiCad design projects/BreakoutSI4463PRORev2/BreakoutSI4463PRORev2.kicad_pcb

Parts:
J1: Conn_Coaxial; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J2: Conn_01x02_Female; Socket_Strip_Straight_1x02_Pitch2.54mm
J3: Conn_01x12_Female; Socket_Strip_Straight_1x12_Pitch2.54mm
U1: RF4463PRO_LiteralLayout

Connections:
GND: J1.2 (Ext), J2.2, J3.1, J3.12, U1.1 (GND), U1.12 (GND), U1.13 (GND)
unnamed: J1.1 (In), J2.1, U1.14 (ANT)
unnamed: J3.2, U1.11 (SDN)
unnamed: J3.3, U1.10 (NIRQ)
unnamed: J3.4, U1.9 (NSEL)
unnamed: J3.5, U1.8 (SCLK)
unnamed: J3.6, U1.7 (SDI)
unnamed: J3.7, U1.6 (SDO)
unnamed: J3.8, U1.5 (VCC)
unnamed: J3.9, U1.4 (GPIO1)
unnamed: J3.10, U1.3 (GPIO0)
unnamed: J3.11, U1.2 (NC)

Board: 2 copper layers, 35.6 x 30.5 mm, 4 parts (0 on the bottom side), 12 nets.

## KiCad design projects/PicoTrackerWSPR2Rev2/PicoTrackerWSPR2Rev2.kicad_pcb

Board: 2 copper layers, 42.9 x 29.5 mm, 50 parts (2 on the bottom side), 28 nets.

Parts:
C1, C7, C9, C10, C11, C12: .1uF; C_0603_HandSoldering
C2, C3, C8: 22uF; C_0603_HandSoldering
CONN1: NEG; Measurement_Point_Square-SMD-Pad_Big
CONN3: VCC_INPUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN4: GND_INPUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN5: MCU_SER_RXD; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN6: MCU_SER_TXD; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN7: VCC_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN9: SDA_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN10: SCL_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN11: SPI_MISO; Pin_Header_Straight_1x01_Pitch2.54mm
CONN12: SPI_SCK; Pin_Header_Straight_1x01_Pitch2.54mm
CONN13: SPI_RESET; Pin_Header_Straight_1x01_Pitch2.54mm
CONN14: VCC; Pin_Header_Straight_1x01_Pitch2.54mm
CONN15: SPI_MOSI; Pin_Header_Straight_1x01_Pitch2.54mm
CONN16: GND; Pin_Header_Straight_1x01_Pitch2.54mm
CONN17: GPS_SER_OUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN18: GPS_SER_IN; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN19: SIG_A; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN20: SIG_B; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN21: GPS_RF_GND; Measurement_Point_Square-SMD-Pad_Big
CONN22: GPS_RF_IN; Measurement_Point_Square-SMD-Pad_Big
CONN23: WSPR_RF_GND; Measurement_Point_Square-SMD-Pad_Small
CONN24: WSPR_RF_OUT; Measurement_Point_Square-SMD-Pad_Small
CONN25: GND_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN26: VCC_OUTPUT; Measurement_Point_Square-SMD-Pad_Big
D1, D2: LED_Small; LED_0603_HandSoldering
IC1: MCP9808
M4: SI5351A
R1, R2: 220; R_0603_HandSoldering
R3, R4, R6: 10k; R_0603_HandSoldering
R9, R11: 100; R_0603_HandSoldering
R10: 68; R_0603_HandSoldering
TCXO2: CRYSTAL_TCXO_3.2mmWidth_2.5mmHeight; CRYSTAL_3.2mmWidth_2.5mmHeight
U1: UBLOX_MAX-7
U2, U4: SIP32431DNP3-T1GE4
U3: ATMEGA328P-MU

Connections:
GND: C1.1, C2.2, C3.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.2, CONN1.1, CONN4.1, CONN21.1, CONN25.1, D1.1, D2.1, IC1.4, IC1.5, IC1.6, IC1.7, IC1.9, M4.8, R9.2, R11.2, TCXO2.2, U1.1, U1.10, U1.12, U2.2, U2.5, U3.3, U3.5, U3.21, U3.33, U4.2, U4.5
GPS_IN_ENABLE: U3.8, U4.4
GPS_RF_IN: CONN22.1, U1.11
GPS_SER_IN: CONN18.1, U1.3, U3.10
GPS_SER_OUT: CONN17.1, U1.2, U3.11
GPS_VCC: C2.1, U1.8, U4.1
GPS_V_BCKP: U1.6, U3.9
LED_1: R1.2, U3.24
LED_2: R2.2, U3.23
unnamed: D1.2, R1.1
unnamed: D2.2, R2.1
unnamed: M4.2, R10.1, R11.1
unnamed: R9.1, R10.2, TCXO2.3
SCL: CONN10.1, IC1.2, M4.4, R6.2, U3.28
SDA: CONN9.1, IC1.1, M4.5, R4.2, U3.27
SER_RXD: CONN5.1, U3.30
SER_TXD: CONN6.1, U3.31
SIG_A: CONN19.1, U3.14
SIG_B: CONN20.1, U3.25
SPI_MISO: CONN11.1, U3.16
SPI_MOSI: CONN15.1, U3.15
SPI_RESET: CONN13.1, R3.2, U3.29
SPI_SCK: CONN12.1, U3.17
VCC: C1.2, C3.1, C8.1, C9.2, C11.2, C12.1, CONN3.1, CONN7.1, CONN26.1, IC1.8, R3.1, R4.1, R6.1, U2.3, U3.4, U3.6, U3.18, U4.3
WSPR_CLK0_OUT: CONN24.1, M4.10
WSPR_CLK1_OUT: CONN23.1, M4.9
WSPR_ENABLE: U2.4, U3.26
WSPR_VCC: C7.1, C10.2, M4.1, M4.7, TCXO2.1, TCXO2.4, U2.1

## KiCad design projects/BreakoutGPSATGM336H/BreakoutGPSATGM336H.kicad_pcb

Parts:
J1, J2: Conn_01x09_Female; Socket_Strip_Straight_1x09_Pitch2.54mm
U1: UBLOX_MAX-7

Connections:
GND: J1.7, J1.9, J2.9, U1.1 (GND), U1.10 (GND), U1.12 (GND)
unnamed: J1.1, U1.18 (NC)
unnamed: J1.2, U1.17 (SCL)
unnamed: J1.3, U1.16 (SDA)
unnamed: J1.4, U1.15 (NC)
unnamed: J1.5, U1.14 (VCC_RF)
unnamed: J1.6, U1.13 (NC)
unnamed: J1.8, U1.11 (RF_IN)
unnamed: J2.1, U1.9 (RESET)
unnamed: J2.2, U1.8 (VCC)
unnamed: J2.3, U1.7 (NC)
unnamed: J2.4, U1.6 (VBAT)
unnamed: J2.5, U1.5 (EN)
unnamed: J2.6, U1.4 (1PPS)
unnamed: J2.7, U1.3 (RXD)
unnamed: J2.8, U1.2 (TXD)

Board: 2 copper layers, 35.6 x 25.4 mm, 3 parts (0 on the bottom side), 16 nets.

## KiCad design projects/PicoTrackerWSPR1Rev4/PicoTrackerWSPR1Rev4.kicad_pcb

Parts:
C1, C5, C7, C9, C10, C11: .1uF; C_0603_HandSoldering
C2, C4, C6, C8: 22uF; C_0603_HandSoldering
C3: 1uF; C_0603_HandSoldering
CONN1: BATT_NEG; Measurement_Point_Square-SMD-Pad_Big
CONN2: BATT_POS; Measurement_Point_Square-SMD-Pad_Big
CONN3: BATT_INPUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN4: GND_INPUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN5: MCU_SER_RXD; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN6: MCU_SER_TXD; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN7: BATT_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN8: VCC_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN9: SDA_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN10: SCL_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN11: SPI_MISO; Pin_Header_Straight_1x01_Pitch2.54mm
CONN12: SPI_SCK; Pin_Header_Straight_1x01_Pitch2.54mm
CONN13: SPI_RESET; Pin_Header_Straight_1x01_Pitch2.54mm
CONN14: VBATT; Pin_Header_Straight_1x01_Pitch2.54mm
CONN15: SPI_MOSI; Pin_Header_Straight_1x01_Pitch2.54mm
CONN16: GND; Pin_Header_Straight_1x01_Pitch2.54mm
CONN17: GPS_SER_OUT; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN18: GPS_SER_IN; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN19: SIG_A; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN20: SIG_B; Socket_Strip_Straight_1x01_Pitch2.54mm
CONN21: GPS_RF_GND; Measurement_Point_Square-SMD-Pad_Big
CONN22: GPS_RF_IN; Measurement_Point_Square-SMD-Pad_Big
CONN23: WSPR_RF_GND; Measurement_Point_Square-SMD-Pad_Small
CONN24: WSPR_RF_OUT; Measurement_Point_Square-SMD-Pad_Small
CONN25: GND_TAP; Socket_Strip_Straight_1x01_Pitch2.54mm
D1, D2: LED_Small; LED_0603_HandSoldering
J1: Conn_01x02; CUT_TRACE
L1: 2.2uH; coilcraft-LPS3015-222
M1, M2: SIP32431DR3-T1GE3; SOT-363_SC-70-6_Handsoldering
M3: UBLOX_NEO-6
M4: SI5351A
R1, R2: 220; R_0603_HandSoldering
R3, R4, R6: 10k; R_0603_HandSoldering
R5: R_Small; R_0603_HandSoldering
R7, R8: 1M; R_0603_HandSoldering
R9, R11: 100; R_0603_HandSoldering
R10: 68; R_0603_HandSoldering
REG_3V3_BOARD1: TPS61201; texas-S-PDSO-N10
TCXO1, TCXO2: CRYSTAL_TCXO_3.2mmWidth_2.5mmHeight; CRYSTAL_3.2mmWidth_2.5mmHeight
TH1: PT100; PTS060301B100RP100
U1: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, CONN1.1, CONN4.1, CONN21.1, CONN23.1, CONN25.1, D1.1 (K), D2.1 (K), M1.2 (GND), M1.5 (GND), M2.2 (GND), M2.5 (GND), M3.7_VD (7_VDDUSB), M3.10_G (10_GND), M3.12_G (12_GND), M3.13_G (13_GND), M3.24_G (24_GND), M4.8 (GND), R8.1, R9.2, R11.2, REG_3V3_BOARD1.4 (PGND), REG_3V3_BOARD1.9 (GND), REG_3V3_BOARD1.PP, REG_3V3_BOARD1.PP@1 (PP), REG_3V3_BOARD1.PP@2 (PP), TCXO1.2, TCXO2.2, TH1.1, U1.3 (GND), U1.5 (GND), U1.21 (GND)
GPS_ENABLE: M1.3 (ON/OFF), U1.12 ((PCINT0/CLKO/ICP1)PB0)
GPS_RF_IN: CONN22.1, M3.11_R (11_RF_IN)
GPS_SER_IN: CONN18.1, M3.21_R (21_RXD1), U1.24 ((PCINT9/ADC1)PC1)
GPS_SER_OUT: CONN17.1, M3.20_T (20_TXD1), U1.23 ((PCINT8/ADC0)PC0)
GPS_VCC: C5.1, M1.1 (OUT), M3.23_V (23_VCC)
GPS_V_BCKP: J1.1, U1.1 ((PCINT19/OC2B/INT1)PD3)
LED_1: R1.2, U1.10 ((PCINT22/OC0A/AIN0)PD6)
LED_2: R2.2, U1.11 ((PCINT23/AIN1)PD7)
unnamed: C3.1, REG_3V3_BOARD1.1 (VAUX)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: J1.2, M3.22_V (22_V_BCKP)
unnamed: L1.2, REG_3V3_BOARD1.3 (L)
unnamed: M3.8_RE (8_RESERVED), M3.9_VC (9_VCC_RF)
unnamed: M4.2 (XA), R10.1, R11.1
unnamed: R9.1, R10.2, TCXO2.3
unnamed: TCXO1.3, U1.7 ((PCINT6/XTAL1/TOSC1)PB6)
REG_PS_CTL: REG_3V3_BOARD1.8 (PS), U1.2 ((PCINT20/XCK/T0)PD4)
SCL: CONN10.1, M4.4 (SCL), R6.2, U1.28 ((PCINT13/SCL/ADC5)PC5)
SDA: CONN9.1, M4.5 (SDA), R4.2, U1.27 ((PCINT12/SDA/ADC4)PC4)
SER_RXD: CONN5.1, U1.30 ((PCINT16/RXD)PD0)
SER_TXD: CONN6.1, U1.31 ((PCINT17/TXD)PD1)
SIG_A: CONN19.1, U1.14 ((PCINT2/OC1B/~SS~)PB2)
SIG_B: CONN20.1, U1.32 ((PCINT18/INT0)PD2)
SPI_MISO: CONN11.1, U1.16 ((PCINT4/MISO)PB4)
SPI_MOSI: CONN15.1, U1.15 ((PCINT3/OC2A/MOSI)PB3)
SPI_RESET: CONN13.1, R3.2, U1.29 ((PCINT14/~RESET~)PC6)
SPI_SCK: CONN12.1, U1.17 ((PCINT5/SCK)PB5)
TEMP_ENABLE: R5.1, U1.9 ((PCINT21/OC0B/T1)PD5)
VBATT: C2.1, CONN2.1, CONN3.1, CONN7.1, L1.1, R7.2, REG_3V3_BOARD1.5 (VIN), REG_3V3_BOARD1.6 (EN), REG_3V3_BOARD1.7 (UVLO)
VBATT_SENSE: R7.1, R8.2, U1.26 ((PCINT11/ADC3)PC3)
VCC: C1.1, C4.1, C6.2, C8.2, C9.1, C11.1, CONN8.1, M1.4 (IN), M2.4 (IN), R3.1, R4.1, R6.1, REG_3V3_BOARD1.2 (VOUT), REG_3V3_BOARD1.10 (FB), TCXO1.1, TCXO1.4, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U1.20 (AREF)
VTEMP_SENSE: R5.2, TH1.2, U1.25 ((PCINT10/ADC2)PC2)
WSPR_ENABLE: M2.3 (ON/OFF), U1.13 ((PCINT1/OC1A)PB1)
WSPR_RF_OUT: CONN24.1, M4.10 (CLK0)
WSPR_VCC: C7.1, C10.2, M2.1 (OUT), M4.1 (VDD), M4.7 (VDDO), TCXO2.1, TCXO2.4

Notes on the sheet:
Break-off Parts
Pullups
Status LEDs
Antenna
Transmitter
GPS
Regulator
Power
Cut Trace for misbehaving modules
AVR
Temperature sensor
TCXO (not mandatory) (fuses dictate)

Board: 2 copper layers, 69.2 x 27.9 mm, 60 parts (2 on the bottom side), 37 nets.

## KiCad design projects/ModuleSolarToStorageTunableLTC3105/ModuleSolarToStorageTunableLTC3105.kicad_pcb

Board: 2 copper layers, 33.0 x 26.0 mm, 18 parts (0 on the bottom side), 9 nets.

Parts:
C1: ??uF; C_0603_HandSoldering
C2: 1uF; C_0603_HandSoldering
C3: ??uF; CP_Tantalum_Case-U_EIA-6032-15_Hand
J1, J1#2: VIN; Socket_Strip_Straight_1x01_Pitch2.54mm
J2, J2#2, J5, J5#2: GND; Socket_Strip_Straight_1x01_Pitch2.54mm
J3, J3#2: VOUT; Socket_Strip_Straight_1x01_Pitch2.54mm
J4, J4#2: LDO; Socket_Strip_Straight_1x01_Pitch2.54mm
L1: 10uH; coilcraft-MSS5131-103
RV1, RV2, RV3: 500k; Potentiometer_Triwood_RM-065
U1: LTC3105EMS-PBF

Connections:
GND: C1.2, C2.2, C3.2, J2.1, J2#2.1, J5.1, J5#2.1, RV1.1, RV2.1, RV3.3, U1.6, U1.7
LDO: J4.1, J4#2.1, RV1.3, U1.2
unnamed: C2.1, U1.12
unnamed: L1.1, U1.9
unnamed: RV1.2, U1.3
unnamed: RV2.2, U1.1
unnamed: RV3.2, U1.5
VIN: C3.1, J1.1, J1#2.1, L1.2, U1.8
VOUT: C1.1, J3.1, J3#2.1, RV2.3, U1.11

## KiCad design projects/ModuleSolarToStorageLTC3105/ModuleSolarToStorageLTC3105.kicad_pcb

Parts:
C1: ??uF; C_0603_HandSoldering
C2: 1uF; C_0603_HandSoldering
C3: ??uF; CP_Tantalum_Case-U_EIA-6032-15_Hand
J1: VIN; Socket_Strip_Straight_1x01_Pitch2.54mm
J2, J5: GND; Socket_Strip_Straight_1x01_Pitch2.54mm
J3: VOUT; Socket_Strip_Straight_1x01_Pitch2.54mm
J4: LDO; Socket_Strip_Straight_1x01_Pitch2.54mm
L1: 10uH; coilcraft-MSS5131-103
R1, R2, R3, R4, R5: R_Small; R_0603_HandSoldering
U1: LTC3105EMS-PBF

Connections:
GND: C1.2, C2.2, C3.2, J2.1, J5.1, R2.2, R4.2, R5.2, U1.6 (GND), U1.7 (GND)
LDO: J4.1, R3.1, U1.2 (LDO)
unnamed: C2.1, U1.12 (AUX)
unnamed: L1.1, U1.9 (SW)
unnamed: R1.2, R2.1, U1.1 (FB)
unnamed: R3.2, R4.1, U1.3 (FBLDO)
unnamed: R5.1, U1.5 (MPPC)
VIN: C3.1, J1.1, L1.2, U1.8 (VIN)
VOUT: C1.1, J3.1, R1.1, U1.11 (VOUT)

Board: 2 copper layers, 19.8 x 16.8 mm, 15 parts (0 on the bottom side), 9 nets.

## Commit log

2018-01-27 KiCad initial setup and custom libraries working
2018-01-29 KiCad PicoTracker1 mid-development checkin
2018-01-30 KiCad PicoTracker1 pcb done
2018-02-18 KiCad created breakouts for si4463 and ublox gps
2018-03-22 KiCad Breakout boards for TPS61201 and RFSI4463PRO
2018-03-24 KiCad PicoTracker1Rev2
2018-04-15 AVR KiCad added parts relating to WSRP tracker, plus adafruit lib
2018-04-15 AVR KiCad PicoTrackerWSPR1
2018-05-07 KiCAD PicoTracker1Rev2 gerbers for upload to hackvana
2018-06-05 KiCad BreakoutTPS6120XWithLayout to investigate regulator issues
2018-09-30 KiCad lib add switch, coincell holder, QFN25
2018-09-30 EvilEye working, DRC pass, no silk yet
2018-09-30 KiCad PCB artwork structure initial checkin
2018-09-30 KiCad EvilEye final
2018-09-30 KiCad BreakoutCAP1188
2018-10-02 KiCad added face logo
2018-10-02 KiCad DemoBoard1, a heart shape for mom
2018-10-21 KiCad EvilEye twaeaks and artifacts of upgrading to 5.0
2019-02-13 KiCad created template project
2019-02-13 KiCad added LTC3105 schematic and footprint
2019-02-19 KiCad updated libs to support LTC3105 energy harvester and MSS5131-103 power inductor
2019-02-19 KiCad LTC3105 Energy Harvester Breakout
2019-02-19 KiCad ModuleSolarToStorageLTC3105
2019-02-20 KiCad initial dup of WSPR tracker before modifications
2019-02-21 KiCad updated symbols to support AVR with no DRC issues, footprints to have longer pads on SI5351 plus cut trace connector
2019-02-21 KiCad PicoTrackerWSPR1Rev2 schematic good, pcb in progress
2019-02-23 KiCad PicoTrackerWSPR1Rev2 complete
2019-02-26 KiCad PicoTrackerWSPR1Rev2 added forgotten battery sense voltage divider
2019-03-29 KiCad CustomSchematicLib change GPS pin 8 to be power in so it can attach to pin 9 with no error
2019-03-29 KiCad PicoTrackerWSPR1Rev3 done
2019-03-29 KiCad change regulator footprint to correct stencil pattern
2019-03-29 KiCad PicoTrackerWSPR1Rev3 update to make stencil creation work
2019-03-29 KiCad PicoTrackerWSPR1Rev3 paste gerber created for stencil
2019-03-30 KiCad ModuleSolarToStorageLTC3105 Rev2
2019-03-30 KiCad ModuleSolarToStorageTunableLTC3105 Rev1
2019-04-08 KiCad PicoTrackerWSPR1Rev3 updated cap value on CLKGEN power input from 10uF to .1uF
2019-04-23 KiCad AVR schematic updated to be literal TQFP arranged
2019-04-23 KiCad PicoTrackerWSPR1Rev4 forked and updated to use TQFP AVR symbol
2019-05-01 KiCad TCXO symbol and footprints
2019-05-01 KiCad remove temporary file
2019-05-01 KiCad PicoTrackerWSPR1Rev4 done
2019-05-01 KiCad PicoTrackerWSPR1Rev4 gerbers generated
2019-05-22 KiCad PicoTrackerWSPR1Rev5
2019-05-24 KiCad PicoTracker1Rev2 gerbers
2019-05-25 Adding README
2020-02-17 added temp sensor MCP9808 schematic and footprint
2020-02-17 added load switch SIP32431DNP3-T1GE4
2020-02-17 added ATMEGA328P-MU footprint
2020-02-18 PicoTrackerWSPR1Rev6
2020-02-18 PicoTrackerWSPR1Rev6 gerbers
2020-02-29 BreakoutGPSATGM336H
2020-03-16 PicoTrackerWSPR2Rev1
2020-03-16 PicoTrackerWSPR2Rev1 silkscreen
2020-03-16 PicoTrackerWSPR2Rev1 gerbers
2020-03-16 BreakoutGPSATGM336H gerbers
2020-04-08 PicoTrackerWSPR2Rev2
2020-04-08 PicoTrackerWSPR2Rev2 gerbers
2020-06-27 KiCad add coax footprints
2020-06-27 KiCad SI4463Pro Literal Layout schematic and footprint
2020-06-27 KiCad BreakoutSI4463PRORev2/
2020-06-27 BreakoutSI4463PRORev2 gerbers
2020-07-12 SMA EdgeMount BackOnly footprint
2020-07-12 BreakoutSI4463PRORev3
2020-07-12 BreakoutSI4463PRORev3 gerbers
2020-08-26 mosfet and regulator schematics/footprints
2020-08-26 BikeLightComputer in-progress
2020-08-28 BikeLightComputer done
2020-08-28 BikeLightComputer gerbers
2020-08-28 BikeLightComputer Rev2

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
